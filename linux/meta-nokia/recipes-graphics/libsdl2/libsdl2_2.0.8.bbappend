FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://fix_directfb_config.patch"
