FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto:"
COMPATIBLE_MACHINE_nokia = "nokia"
SRC_URI += "file://fbtft.cfg"
